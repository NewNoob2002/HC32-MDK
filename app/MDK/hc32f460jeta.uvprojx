# Keil uVision project hc32f460jeta.uvprojx, settings and files
target hc32f460jeta_Debug (6160000::V6.16::ARMCLANG)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f460jeta +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ..\source;..\..\bsp\ev_hc32f460_lqfp100_v2;..\..\CMSIS\Include;..\..\CMSIS\Device\HDSC\hc32f4xx\Include;..\..\Driver\inc;..\..\Libraries\MillisTaskManager;..\..\Libraries\HardWareI2C;..\..\Arduino;..\..\Arduino\Core\avr;..\..\Arduino\Core\drivers\gpio;..\..\Arduino\Core\drivers\adc;..\..\Arduino\Core\drivers\panic;..\..\Arduino\Core\drivers\irqn;..\..\Arduino\Core\drivers\sysclock;..\..\Arduino\Core\variants\hc32f460xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group App
    ../source/: main.cpp
  group Arduino
    ../../Arduino/Core/variants/hc32f460xx/: variant.cpp
    ../../Arduino/: wiring_digital.cpp wiring_digital.h WString.cpp WMath.cpp itoa.c Print.cpp Stream.cpp
    ../../Arduino/Core/drivers/adc/: adc.cpp adc_config.cpp
    ../../Arduino/Core/drivers/gpio/: addon_gpio.c
    ../../Arduino/Core/drivers/sysclock/: sysclock.cpp systick.cpp
    ../../Arduino/Core/avr/: dtostrf.c
    ../../Arduino/Core/drivers/irqn/: irqn.cpp
  group bsp
    ../../bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group cmsis
    ../../CMSIS/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../../CMSIS/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
  group driver
    ../../Driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group library
    ../../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../../Libraries/HardWareI2c/: HardwareI2c.cpp
software components: CMSIS:CORE 5.5.0
