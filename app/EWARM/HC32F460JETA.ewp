# IAR project HC32F460JETA.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f460jeta.hex
  ILINK.IlinkOutputFile: hc32f460jeta.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_=1; _HC32F460_512K_=1
  ILINK.IlinkIcfFile: config/linker/HC32F460.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DDL_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group cmsis
    ../../common/: system_hc32f460jeta.c
    ./: startup_hc32f460jeta.s
  group source
    ../source/: main.c
